# Keil uVision project robot_keil_etudiant.uvproj, settings and files
target Target 1 (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: robot_keil_etudiant +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group appilcation
    ./: putchar_robot_09.OBJ getkey_robot_09.OBJ test_keil_robot.c
  group librairie
    ./: robotlib_2009.LIB
